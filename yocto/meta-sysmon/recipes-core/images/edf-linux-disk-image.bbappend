IMAGE_INSTALL:append = " sysmon-web"
